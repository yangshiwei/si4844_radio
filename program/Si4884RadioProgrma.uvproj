# Keil uVision project Si4884RadioProgrma.uvproj, settings and files
target Debug (MCS-51)
  device: C8051F340 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: Si4884RadioProgrma
  c flags: SizeSpeed=1
  c include: .\oled;.\app;.\si4844;.\system
  group OLED
    ./oled/: OLED.c
  group SYSTEM
    ./system/: Init_Device.c
  group APP
    ./app/: radio.c delay.c
